# Keil uVision project ShortTeam2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ShortTeam2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Src
  group Source Group 1
    ./: STARTUP.A51
    ./Src/: 24C08.c DS1302.c Timer.c Main.c DigitalTube.c Key.c Alarm.c
