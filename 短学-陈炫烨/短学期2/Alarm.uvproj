# Keil uVision project Alarm.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Alarm +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c mian.h DS1302.c DS1302.h Key.c 24C08.c 24C08.h Delay.c Delay.h DisPlay.h DisPlay.c Alarm.h Alarm.c
